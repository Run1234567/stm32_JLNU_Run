# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --diag_suppress=1
  c include: .\Start;.\User;.\Library;.\Library_RUN;.\Library_Device_RUN;.\Library_Algorithm_RUN
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_hd.s
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Library_RUN
    ./Library_RUN/: RUN_Gpio.c RUN_Gpio.h RUN_UART.c RUN_UART.h RUN_Isr.c RUN_Isr.h RUN_header_file.h RUN_Timer.c RUN_Timer.h RUN_PWM.c RUN_PWM.h RUN_Delay.c RUN_Delay.h RUN_Exti.c RUN_Exti.h RUN_SoftI2C.c RUN_SoftI2C.h RUN_ADC.c RUN_ADC.h RUN_Flash.c RUN_Flash.h RUN_SPI.c RUN_SPI.h RUN_OneWire.c RUN_OneWire.h RUN_DAC.c RUN_DAC.h RUN_DMA.c RUN_DMA.h RUN_CAN.c RUN_CAN.h
  group Library_Device_RUN
    ./Library_Device_RUN/: RUN_MPU6050.c RUN_MPU6050.h RUN_AT24C02.c RUN_AT24C02.h RUN_W25Q64.c RUN_W25Q64.h RUN_DS18B20.c RUN_DS18B20.h RUN_Moter_Brushed.c RUN_Moter_Brushed.h RUN_Moter_Stepper.c RUN_Moter_Stepper.h
  group Library_Algorithm_Run
    ./Library_Algorithm_Run/: RUN_IMU_GetAngle.c RUN_IMU_GetAngle.h RUN_PID.c RUN_PID.h RUN_Str.c RUN_Str.h
